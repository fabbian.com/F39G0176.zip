Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Lighting_Wall-Mounted_Fabbian-Illuminazione_Pivot-F39G01.ifc
Time: 2018-12-03T01:27:41
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Pivot F39G01
ePset_BIMobjectScript - Color: White; LOD: 300; Angle: 0
ePset_BIMobject_BO - ProductName (BO_prodinfo): Pivot F39G01; SKU (BO_prodsku): Pivot-F39G01; ManufacturName (BO_Manufac): Fabbian Illuminazione; BrandUrl (BO_brandurl): http://www.fabbian.com; ProductFamily (BO_prodfam): Pivot; ProductGroup (BO_prodgroup): Wall-Ceiling lamp; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; PublishDate (BO_publisdat): 4/27/1918; EditionNumber (BO_edinum): 1; Width (BO_width): 572; Height (BO_height): 50; Depth (BO_depth): 40; Weight (BO_weight): 0.45; QR (BO_boqrurl): http://bimobject.com/fabbian/product/Pivot-F39G01; ProductDataUrl (BO_prodaturl): bimobject.com/fabbian/product/Pivot-F39G01; ProductUrl (BO_producturl): http://www.fabbian.com/en/f39-pivot-0; InstallationInstructions (BO_montins): http://www.fabbian.com/sites/default/files//prodotti/montaggio-pdf/F39G0101.pdf; TechnicalDescription (BO_techcert): http://files.fabbian.com/fabbian.com/BIM/F39G01-en.pdf; MaterialMain (BO_mainmat): Aluminium; BimObjectMainCategory (BO_bomaincat): Lighting; BimObjectMainCategoryCode (BO_bomaincat_code): lighting; BimObjectCategory (BO_bocat): Wall Mounted; BimObjectCategoryCode (BO_bocat_code): lighting-wall-mounted; IfcClassification (BO_ifcclas): Light Fixture; UnspcCode (BO_unspc): 3911; Uniclass14Code (BO_uniclass_1_4_code): L7473; Uniclass14Description (BO_uniclass_1_4_desc): Fixed luminaires (lighting fittings); Uniclass20Code (BO_uniclass_2_0_code): SS-70-80; Uniclass20Description (BO_uniclass_2_0_desc): Lighting Systems; Uniclass2015Code (BO_uniclass2015_code): Ss_70_80; Uniclass2015Description (BO_uniclass2015_desc): Lighting systems; NBSReference (BO_nbs_ref): 70-80; NBSReferenceDescription (BO_nbs_desc): Lighting Systems; OmniClassCode (BO_omniclass_code): 23-35 47 11; OmniClassDescription (BO_omniclass_name): Lighting Fixtures; MasterFormat2014Code (BO_masterformat2014_code): 26 51 13; MasterFormat2014Description (BO_masterformat2014_name): Interior Lighting Fixtures, Lamps, And Ballasts; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
